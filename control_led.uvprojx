# Keil uVision project control_led.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: control_led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: .\MCAL\inc;.\Config\inc;.\Common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/: GPIO.c int_ctr.c sys_tick.c
  group config
    ./Config/: IntCtrl_Cfg.c
  group APPL
    ./APPL/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
